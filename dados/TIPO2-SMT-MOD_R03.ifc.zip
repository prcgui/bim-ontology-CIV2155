Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView_V1.2]ExchangeRequirement]
File name: TIPO2-SMT-MOD_R03.ifc
Time: 2025-10-30T09:58:56+00:00
Author: Engenheiro Civil
Organization: FUNDO NACIONAL DE DESENVOLVIMENTO DA EDUCAÇÃO - FNDE
Written by: IfcOpenShell 0.8.3-post1
Made in: Bonsai 0.8.3-post1

# IfcProject, PROJETO PADRÃO FNDE
Description: CRECHE PRÉ-ESCOLA TIPO 2; LongName: PROJETO DE ESTRUTURA METÁLICA; Phase: PROJETO PADRÃO

# IfcBuildingStorey, COBERTURA
In: CRECHE PRÉ-ESCOLA TIPO 2
Elevation: 0 mm

# IfcBeam (2518)
In: COBERTURA
Material: ASTM A36
Name | Description | Pset_BeamCommon, Status | Pset_BeamCommon, Slope | Pset_BeamCommon, Roll | Pset_BeamCommon, IsExternal = Pset_BeamCommon, LoadBearing | Qto_BeamBaseQuantities, Length (mm) | Qto_BeamBaseQuantities, CrossSectionArea (m2) | Qto_BeamBaseQuantities, OuterSurfaceArea (m2) = Qto_BeamBaseQuantities, GrossSurfaceArea (m2) | Qto_BeamBaseQuantities, NetSurfaceArea (m2) | Qto_BeamBaseQuantities, GrossVolume (m3) | Qto_BeamBaseQuantities, NetVolume (m3) | Qto_BeamBaseQuantities, GrossWeight (kg) | Qto_BeamBaseQuantities, NetWeight (kg)
BNZ | U120X60X3.00 | NEW | 1.57078 | 0.00002 | no | 350.003 | 0.00071 | 0.1521 | 0.1521 | 0.00022 | 0.00022 | 1.75115 | 1.75115
18 x BNZ | U120X60X3.00 | NEW | 1.5708 | 0 | no | 978.711 | 0.00071 | 0.44964 | 0.44964 | 0.00066 | 0.00066 | 5.21013 | 5.21013
MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.58906; Roll: 0.98173; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 520 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.21673 m2; GrossSurfaceArea: 0.21673 m2; NetSurfaceArea: 0.21673 m2; GrossVolume: 0.00028 m3; NetVolume: 0.00028 m3; GrossWeight: 2.2143 kg; NetWeight: 2.2143 kg
36 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 790 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.3287 m2; GrossSurfaceArea: 0.3287 m2; NetSurfaceArea: 0.3287 m2; GrossVolume: 0.00043 m3; NetVolume: 0.00043 m3; GrossWeight: 3.36403 kg; NetWeight: 3.36403 kg
17 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 450 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.1877 m2; GrossSurfaceArea: 0.1877 m2; NetSurfaceArea: 0.1877 m2; GrossVolume: 0.00024 m3; NetVolume: 0.00024 m3; GrossWeight: 1.91622 kg; NetWeight: 1.91622 kg
BNZ | U120X60X3.00 | NEW | 0 | 1.5708 | no | 529.081 | 0.00071 | 0.22433 | 0.22433 | 0.00033 | 0.00033 | 2.58497 | 2.58497
17 x BNZ | U120X60X3.00 | NEW | 1.5708 | 0 | no | 186.178 | 0.00071 | 0.06224 | 0.06224 | 0.00009 | 0.00009 | 0.70063 | 0.70063
17 x BNZ | U120X60X3.00 | NEW | 0.06154 | 1.50926 | no | 8171.15 | 0.00071 | 3.8593 | 3.8593 | 0.00571 | 0.00571 | 44.8508 | 44.8508
BNZ | U120X60X3.00 | NEW | 0 | 1.5708 | no | 8624.77 | 0.00071 | 4.07434 | 4.07434 | 0.00603 | 0.00603 | 47.3509 | 47.3509
17 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 520 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.21673 m2; GrossSurfaceArea: 0.21673 m2; NetSurfaceArea: 0.21673 m2; GrossVolume: 0.00028 m3; NetVolume: 0.00028 m3; GrossWeight: 2.2143 kg; NetWeight: 2.2143 kg
18 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 565 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.23539 m2; GrossSurfaceArea: 0.23539 m2; NetSurfaceArea: 0.23539 m2; GrossVolume: 0.00031 m3; NetVolume: 0.00031 m3; GrossWeight: 2.40592 kg; NetWeight: 2.40592 kg
18 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 610 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.25405 m2; GrossSurfaceArea: 0.25405 m2; NetSurfaceArea: 0.25405 m2; GrossVolume: 0.00033 m3; NetVolume: 0.00033 m3; GrossWeight: 2.59755 kg; NetWeight: 2.59755 kg
18 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 695 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.2893 m2; GrossSurfaceArea: 0.2893 m2; NetSurfaceArea: 0.2893 m2; GrossVolume: 0.00038 m3; NetVolume: 0.00038 m3; GrossWeight: 2.9595 kg; NetWeight: 2.9595 kg
18 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 870 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.36187 m2; GrossSurfaceArea: 0.36187 m2; NetSurfaceArea: 0.36187 m2; GrossVolume: 0.00047 m3; NetVolume: 0.00047 m3; GrossWeight: 3.7047 kg; NetWeight: 3.7047 kg
125 x SP | L 115X41X3.00 | NEW | 0 | 0.06154 | no | 140 | 0.00046 | 0.0446 | 0.0446 | 0.00006 | 0.00006 | 0.50444 | 0.50444
17 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 485 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.20221 m2; GrossSurfaceArea: 0.20221 m2; NetSurfaceArea: 0.20221 m2; GrossVolume: 0.00026 m3; NetVolume: 0.00026 m3; GrossWeight: 2.06526 kg; NetWeight: 2.06526 kg
17 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.67227; Roll: 0.89852; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 740.003 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.30796 m2; GrossSurfaceArea: 0.30796 m2; NetSurfaceArea: 0.30796 m2; GrossVolume: 0.0004 m3; NetVolume: 0.0004 m3; GrossWeight: 3.15113 kg; NetWeight: 3.15113 kg
17 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.66034; Roll: 0.91045; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 760.002 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.31626 m2; GrossSurfaceArea: 0.31626 m2; NetSurfaceArea: 0.31626 m2; GrossVolume: 0.00041 m3; NetVolume: 0.00041 m3; GrossWeight: 3.23629 kg; NetWeight: 3.23629 kg
17 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.75096; Roll: 0.81983; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 805.001 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.33492 m2; GrossSurfaceArea: 0.33492 m2; NetSurfaceArea: 0.33492 m2; GrossVolume: 0.00043 m3; NetVolume: 0.00043 m3; GrossWeight: 3.42791 kg; NetWeight: 3.42791 kg
17 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.76287; Roll: 0.80793; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 805.001 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.33492 m2; GrossSurfaceArea: 0.33492 m2; NetSurfaceArea: 0.33492 m2; GrossVolume: 0.00043 m3; NetVolume: 0.00043 m3; GrossWeight: 3.42791 kg; NetWeight: 3.42791 kg
18 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.47663; Roll: 1.09417; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1445 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.60033 m2; GrossSurfaceArea: 0.60033 m2; NetSurfaceArea: 0.60033 m2; GrossVolume: 0.00078 m3; NetVolume: 0.00078 m3; GrossWeight: 6.1532 kg; NetWeight: 6.1532 kg
18 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.4618; Roll: 1.10899; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1510 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.62728 m2; GrossSurfaceArea: 0.62728 m2; NetSurfaceArea: 0.62728 m2; GrossVolume: 0.00082 m3; NetVolume: 0.00082 m3; GrossWeight: 6.43 kg; NetWeight: 6.43 kg
18 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.63562; Roll: 0.93517; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1400 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.58166 m2; GrossSurfaceArea: 0.58166 m2; NetSurfaceArea: 0.58166 m2; GrossVolume: 0.00076 m3; NetVolume: 0.00076 m3; GrossWeight: 5.96158 kg; NetWeight: 5.96158 kg
18 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.59039; Roll: 0.98041; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1500 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.62313 m2; GrossSurfaceArea: 0.62313 m2; NetSurfaceArea: 0.62313 m2; GrossVolume: 0.00081 m3; NetVolume: 0.00081 m3; GrossWeight: 6.3874 kg; NetWeight: 6.3874 kg
70 x CT | L50X4.75 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5093; Roll: 0.04347; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 60 mm; CrossSectionArea: 0.00046 m2; OuterSurfaceArea: 0.0129 m2; GrossSurfaceArea: 0.0129 m2; NetSurfaceArea: 0.0129 m2; GrossVolume: 0.00004 m3; NetVolume: 0.00004 m3; GrossWeight: 0.2131 kg; NetWeight: 0.2131 kg
70 x CT | L50X4.75 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.50926; Roll: 0.0435; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 60 mm; CrossSectionArea: 0.00046 m2; OuterSurfaceArea: 0.0129 m2; GrossSurfaceArea: 0.0129 m2; NetSurfaceArea: 0.0129 m2; GrossVolume: 0.00004 m3; NetVolume: 0.00004 m3; GrossWeight: 0.2131 kg; NetWeight: 0.2131 kg
16 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.5436; Roll: 1.0272; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 560 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.23332 m2; GrossSurfaceArea: 0.23332 m2; NetSurfaceArea: 0.23332 m2; GrossVolume: 0.00031 m3; NetVolume: 0.00031 m3; GrossWeight: 2.38463 kg; NetWeight: 2.38463 kg
16 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.79595; Roll: 0.77485; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 575 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.23954 m2; GrossSurfaceArea: 0.23954 m2; NetSurfaceArea: 0.23954 m2; GrossVolume: 0.00031 m3; NetVolume: 0.00031 m3; GrossWeight: 2.44851 kg; NetWeight: 2.44851 kg
16 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.82021; Roll: 0.75059; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 635 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.26442 m2; GrossSurfaceArea: 0.26442 m2; NetSurfaceArea: 0.26442 m2; GrossVolume: 0.00033 m3; NetVolume: 0.00033 m3; GrossWeight: 2.704 kg; NetWeight: 2.704 kg
16 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.78419; Roll: 0.78661; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 675 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.28101 m2; GrossSurfaceArea: 0.28101 m2; NetSurfaceArea: 0.28101 m2; GrossVolume: 0.00038 m3; NetVolume: 0.00038 m3; GrossWeight: 2.87433 kg; NetWeight: 2.87433 kg
16 x BNZ | U120X60X3.00 | NEW | 0.06044 | 1.51036 | no | 2218.37 | 0.00071 | 1.03768 | 1.03768 | 0.00153 | 0.00153 | 12.0468 | 12.0468
16 x BNZ | U120X60X3.00 | NEW | 0 | 1.5708 | no | 10870 | 0.00071 | 5.13858 | 5.13858 | 0.00761 | 0.00761 | 59.7237 | 59.7237
16 x BNZ | U120X60X3.00 | NEW | 0 | 1.5708 | no | 619.996 | 0.00071 | 0.25477 | 0.25477 | 0.00038 | 0.00038 | 2.93296 | 2.93296
8 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.85842; Roll: 0.71238; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 715.001 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.2976 m2; GrossSurfaceArea: 0.2976 m2; NetSurfaceArea: 0.2976 m2; GrossVolume: 0.0004 m3; NetVolume: 0.0004 m3; GrossWeight: 3.04467 kg; NetWeight: 3.04467 kg
38 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 430 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.17941 m2; GrossSurfaceArea: 0.17941 m2; NetSurfaceArea: 0.17941 m2; GrossVolume: 0.00022 m3; NetVolume: 0.00022 m3; GrossWeight: 1.83106 kg; NetWeight: 1.83106 kg
16 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 455 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.18977 m2; GrossSurfaceArea: 0.18977 m2; NetSurfaceArea: 0.18977 m2; GrossVolume: 0.00024 m3; NetVolume: 0.00024 m3; GrossWeight: 1.93751 kg; NetWeight: 1.93751 kg
16 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 495 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.20636 m2; GrossSurfaceArea: 0.20636 m2; NetSurfaceArea: 0.20636 m2; GrossVolume: 0.00026 m3; NetVolume: 0.00026 m3; GrossWeight: 2.10784 kg; NetWeight: 2.10784 kg
16 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 525 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.2188 m2; GrossSurfaceArea: 0.2188 m2; NetSurfaceArea: 0.2188 m2; GrossVolume: 0.00028 m3; NetVolume: 0.00028 m3; GrossWeight: 2.23559 kg; NetWeight: 2.23559 kg
16 x BNZ | U120X60X3.00 | NEW | 1.5708 | 0 | no | 588.513 | 0.00071 | 0.26469 | 0.26469 | 0.0004 | 0.0004 | 3.05997 | 3.05997
19 x BNZ | U120X60X3.00 | NEW | 1.5708 | 0 | no | 164.527 | 0.00071 | 0.05197 | 0.05197 | 0.00006 | 0.00006 | 0.58123 | 0.58123
60 x SP | L 115X41X3.00 | NEW | 0 | 0.06044 | no | 140 | 0.00046 | 0.0446 | 0.0446 | 0.00006 | 0.00006 | 0.50444 | 0.50444
4 x TC | C120X50X20X2.65 | NEW | 0 | 0.06154 | no | 4305 | 0.00066 | 2.17147 | 2.17147 | 0.00285 | 0.00285 | 22.335 | 22.335
26 x TC | C120X50X20X2.65 | NEW | 0 | 0.06154 | no | 4560 | 0.00066 | 2.30002 | 2.30002 | 0.00301 | 0.00301 | 23.6579 | 23.6579
54 x TC | C120X50X20X2.65 | NEW | 0 | 0.06154 | no | 4175 | 0.00066 | 2.10594 | 2.10594 | 0.00276 | 0.00276 | 21.6605 | 21.6605
4 x TC | C120X50X20X2.65 | NEW | 0 | 0.06154 | no | 4300 | 0.00066 | 2.16895 | 2.16895 | 0.00284 | 0.00284 | 22.309 | 22.309
20 x TC | C120X50X20X2.65 | NEW | 0 | 0.06154 | no | 5300 | 0.00066 | 2.67305 | 2.67305 | 0.0035 | 0.0035 | 27.4972 | 27.4972
4 x TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 5300 | 0.00066 | 2.67305 | 2.67305 | 0.0035 | 0.0035 | 27.4972 | 27.4972
12 x TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 4175 | 0.00066 | 2.10594 | 2.10594 | 0.00276 | 0.00276 | 21.6605 | 21.6605
10 x TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 4295 | 0.00066 | 2.16643 | 2.16643 | 0.00284 | 0.00284 | 22.2831 | 22.2831
4 x TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 4300 | 0.00066 | 2.16895 | 2.16895 | 0.00284 | 0.00284 | 22.309 | 22.309
32 x CR | L43X2.65 | NEW | 0.06154 | 1.50926 | no | 1262.85 | 0.00022 | 0.21765 | 0.21765 | 0.00028 | 0.00028 | 2.18964 | 2.18964
62 x CR | L43X2.65 | NEW | 0.06154 | 1.50926 | no | 1362.85 | 0.00022 | 0.23485 | 0.23485 | 0.00031 | 0.00031 | 2.36303 | 2.36303
24 x CR | L43X2.65 | NEW | 0.06047 | 1.51032 | no | 1052 | 0.00022 | 0.18139 | 0.18139 | 0.00022 | 0.00022 | 1.82404 | 1.82404
112 x SPT | G 60X50X70X6.35 | NEW | 1.50926 | 0.03076 | no | 50 | 0.00109 | 0.02001 | 0.02001 | 0.00004 | 0.00004 | 0.42856 | 0.42856
24 x TR | BARRA.RED.9.53 | NEW | 0.03463 | 1.50926 | no | 2150 | 0.00006 | 0.06286 | 0.06286 | 0.00014 | 0.00014 | 1.08387 | 1.08387
8 x TR | BARRA.RED.9.53 | NEW | 0.03221 | 1.50926 | no | 2350 | 0.00006 | 0.06869 | 0.06869 | 0.00014 | 0.00014 | 1.1847 | 1.1847
24 x TR | BARRA.RED.9.53 | NEW | 0.02957 | 1.51036 | no | 2050 | 0.00006 | 0.05994 | 0.05994 | 0.00014 | 0.00014 | 1.03346 | 1.03346
8 x CV | BARRA.RED.9.53 | NEW | 0.02858 | 0.05449 | no | 5000 | 0.00006 | 0.14601 | 0.14601 | 0.00032 | 0.00032 | 2.52064 | 2.52064
8 x CV | BARRA.RED.9.53 | NEW | 0.02858 | 0.05445 | no | 5000 | 0.00006 | 0.14601 | 0.14601 | 0.00032 | 0.00032 | 2.52064 | 2.52064
8 x CV | BARRA.RED.9.53 | NEW | 0.03056 | 0.05342 | no | 5000 | 0.00006 | 0.14601 | 0.14601 | 0.00032 | 0.00032 | 2.52064 | 2.52064
8 x CV | BARRA.RED.9.53 | NEW | 0.03055 | 0.05342 | no | 5000 | 0.00006 | 0.14601 | 0.14601 | 0.00032 | 0.00032 | 2.52064 | 2.52064
8 x CV | BARRA.RED.9.53 | NEW | 0.03064 | 0.05333 | no | 5000 | 0.00006 | 0.14601 | 0.14601 | 0.00032 | 0.00032 | 2.52064 | 2.52064
8 x CV | BARRA.RED.9.53 | NEW | 0.03063 | 0.05334 | no | 5000 | 0.00006 | 0.14601 | 0.14601 | 0.00032 | 0.00032 | 2.52064 | 2.52064
16 x CV | BARRA.RED.9.53 | NEW | 0.02356 | 0.05542 | no | 4800 | 0.00006 | 0.14017 | 0.14017 | 0.00031 | 0.00031 | 2.41981 | 2.41981
36 x MF | L50X3.0 | NEW | 0.8754 | 0.69538 | no | 915 | 0.00029 | 0.18358 | 0.18358 | 0.00026 | 0.00026 | 2.09018 | 2.09018
20 x SP | L 115X41X3.00 | NEW | 0 | 0.06154 | no | 60 | 0.00046 | 0.01964 | 0.01964 | 0.00004 | 0.00004 | 0.21619 | 0.21619
4 x CT | L64X4.8 | NEW | 0.06154 | 1.50926 | no | 5510 | 0.00058 | 0 | 1.40071 | 0.0032 | 0.00323 | 25.087 | 25.3708
8 x CT | L64X4.8 | NEW | 0.06044 | 0 | no | 100 | 0.00058 | 0 | 0.02657 | 0.00006 | 0.00006 | 0.4553 | 0.46045
8 x SP | L 115X41X3.00 | NEW | 0 | 0.06044 | no | 60 | 0.00046 | 0.01964 | 0.01964 | 0.00004 | 0.00004 | 0.21619 | 0.21619
4 x CT | L64X4.8 | NEW | 0 | 0 | no | 925 | 0.00058 | 0 | 0.23612 | 0.00054 | 0.00054 | 4.21153 | 4.25916
6 x CT | L64X4.8 | NEW | 0 | 0 | no | 2500 | 0.00058 | 0 | 0.63617 | 0.00145 | 0.00147 | 11.3825 | 11.5112
3 x BNZ | U120X60X3.00 | NEW | 1.5708 | 0 | no | 210.004 | 0.00071 | 0.07309 | 0.07309 | 0.00011 | 0.00011 | 0.82663 | 0.82663
3 x BNZ | U120X60X3.00 | NEW | 0 | 1.5708 | no | 180.06 | 0.00071 | 0.05889 | 0.05889 | 0.00009 | 0.00009 | 0.66162 | 0.66162
3 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 530 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.22088 m2; GrossSurfaceArea: 0.22088 m2; NetSurfaceArea: 0.22088 m2; GrossVolume: 0.00028 m3; NetVolume: 0.00028 m3; GrossWeight: 2.25688 kg; NetWeight: 2.25688 kg
3 x BNZ | U120X60X3.00 | NEW | 0 | 1.5708 | no | 2017.21 | 0.00071 | 0.94235 | 0.94235 | 0.00139 | 0.00139 | 10.9386 | 10.9386
3 x BNZ | U120X60X3.00 | NEW | 0 | 1.5708 | no | 382.952 | 0.00071 | 0.15506 | 0.15506 | 0.00022 | 0.00022 | 1.77967 | 1.77967
3 x BNZ | U120X60X3.00 | NEW | 0.06044 | 1.51036 | no | 1817.64 | 0.00071 | 0.84773 | 0.84773 | 0.00125 | 0.00125 | 9.83849 | 9.83849
3 x BNZ | U120X60X3.00 | NEW | 1.5708 | 0 | no | 414.307 | 0.00071 | 0.18212 | 0.18212 | 0.00026 | 0.00026 | 2.09997 | 2.09997
3 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 465 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.19392 m2; GrossSurfaceArea: 0.19392 m2; NetSurfaceArea: 0.19392 m2; GrossVolume: 0.00024 m3; NetVolume: 0.00024 m3; GrossWeight: 1.9801 kg; NetWeight: 1.9801 kg
3 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.86703; Roll: 0.70377; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 400 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.16696 m2; GrossSurfaceArea: 0.16696 m2; NetSurfaceArea: 0.16696 m2; GrossVolume: 0.00022 m3; NetVolume: 0.00022 m3; GrossWeight: 1.70331 kg; NetWeight: 1.70331 kg
3 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.74076; Roll: 0.83004; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 665 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.27686 m2; GrossSurfaceArea: 0.27686 m2; NetSurfaceArea: 0.27686 m2; GrossVolume: 0.00036 m3; NetVolume: 0.00036 m3; GrossWeight: 2.83175 kg; NetWeight: 2.83175 kg
3 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.75404; Roll: 0.81676; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 635 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.26442 m2; GrossSurfaceArea: 0.26442 m2; NetSurfaceArea: 0.26442 m2; GrossVolume: 0.00033 m3; NetVolume: 0.00033 m3; GrossWeight: 2.704 kg; NetWeight: 2.704 kg
3 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 500 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.20843 m2; GrossSurfaceArea: 0.20843 m2; NetSurfaceArea: 0.20843 m2; GrossVolume: 0.00026 m3; NetVolume: 0.00026 m3; GrossWeight: 2.12914 kg; NetWeight: 2.12914 kg
3 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.99235; Roll: 0.57844; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 600 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.2499 m2; GrossSurfaceArea: 0.2499 m2; NetSurfaceArea: 0.2499 m2; GrossVolume: 0.00033 m3; NetVolume: 0.00033 m3; GrossWeight: 2.55496 kg; NetWeight: 2.55496 kg
3 x BNZ | U120X60X3.00 | NEW | 1.57079 | 0.00001 | no | 349.959 | 0.00071 | 0.15209 | 0.15209 | 0.00022 | 0.00022 | 1.75097 | 1.75097
2 x BNZ | C150X60X30X3.75 | NEW | 0 | 0 | no | 8480 | 0.00118 | 5.40836 | 5.40836 | 0.01002 | 0.01002 | 78.6334 | 78.6334
2 x TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 4245 | 0.00066 | 2.14123 | 2.14123 | 0.00281 | 0.00281 | 22.0237 | 22.0237
8 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.85043; Roll: 0.72036; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 715.001 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.2976 m2; GrossSurfaceArea: 0.2976 m2; NetSurfaceArea: 0.2976 m2; GrossVolume: 0.0004 m3; NetVolume: 0.0004 m3; GrossWeight: 3.04467 kg; NetWeight: 3.04467 kg
TC | C120X50X20X2.65 | NEW | 0 | 0.06154 | no | 5350 | 0.00066 | 2.69826 | 2.69826 | 0.00354 | 0.00354 | 27.7566 | 27.7566
TC | C120X50X20X2.65 | NEW | 0 | 0.06154 | no | 5600 | 0.00066 | 2.82428 | 2.82428 | 0.0037 | 0.0037 | 29.0536 | 29.0536
TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 5350 | 0.00066 | 2.69826 | 2.69826 | 0.00354 | 0.00354 | 27.7566 | 27.7566
TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 5600 | 0.00066 | 2.82428 | 2.82428 | 0.0037 | 0.0037 | 29.0536 | 29.0536
4 x TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 4305 | 0.00066 | 2.17147 | 2.17147 | 0.00285 | 0.00285 | 22.335 | 22.335
MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.61102; Roll: 0.95978; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 935 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.38883 m2; GrossSurfaceArea: 0.38883 m2; NetSurfaceArea: 0.38883 m2; GrossVolume: 0.00051 m3; NetVolume: 0.00051 m3; GrossWeight: 3.98148 kg; NetWeight: 3.98148 kg
MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.64047; Roll: 0.93033; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 910 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.37846 m2; GrossSurfaceArea: 0.37846 m2; NetSurfaceArea: 0.37846 m2; GrossVolume: 0.00049 m3; NetVolume: 0.00049 m3; GrossWeight: 3.87503 kg; NetWeight: 3.87503 kg
BNZ | U120X60X3.00 | NEW | 0 | 1.5708 | no | 7005.76 | 0.00071 | 3.30693 | 3.30693 | 0.0049 | 0.0049 | 38.429 | 38.429
BNZ | U120X60X3.00 | NEW | 1.5708 | 0 | no | 547.014 | 0.00071 | 0.24593 | 0.24593 | 0.00036 | 0.00036 | 2.84215 | 2.84215
BNZ | U120X60X3.00 | NEW | 0.06154 | 1.50926 | no | 7019.07 | 0.00071 | 3.31321 | 3.31321 | 0.0049 | 0.0049 | 38.502 | 38.502
2 x TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 2965 | 0.00066 | 1.49598 | 1.49598 | 0.00196 | 0.00196 | 15.3828 | 15.3828
2 x CR | L43X2.65 | NEW | 0.06027 | 1.51053 | no | 1487.76 | 0.00022 | 0.25634 | 0.25634 | 0.00033 | 0.00033 | 2.5796 | 2.5796
2 x TC | C120X50X20X2.65 | NEW | 0 | 0.06044 | no | 3215 | 0.00066 | 1.622 | 1.622 | 0.00212 | 0.00212 | 16.6799 | 16.6799
4 x CT | L200X125X12.7 | NEW | 1.5708 | 0 | no | 180 | 0.00394 | 0.12301 | 0.12301 | 0.0007 | 0.0007 | 5.51453 | 5.51453
2 x DG | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.23477; Roll: 0.33602; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 960 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.3992 m2; GrossSurfaceArea: 0.3992 m2; NetSurfaceArea: 0.3992 m2; GrossVolume: 0.00052 m3; NetVolume: 0.00052 m3; GrossWeight: 4.08794 kg; NetWeight: 4.08794 kg
2 x DG | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.8949; Roll: 0.67589; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1140 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.47384 m2; GrossSurfaceArea: 0.47384 m2; NetSurfaceArea: 0.47384 m2; GrossVolume: 0.00062 m3; NetVolume: 0.00062 m3; GrossWeight: 4.85443 kg; NetWeight: 4.85443 kg
2 x DG | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.84247; Roll: 0.72833; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1200 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.49872 m2; GrossSurfaceArea: 0.49872 m2; NetSurfaceArea: 0.49872 m2; GrossVolume: 0.00065 m3; NetVolume: 0.00065 m3; GrossWeight: 5.10993 kg; NetWeight: 5.10993 kg
10 x MT | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 920 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.38261 m2; GrossSurfaceArea: 0.38261 m2; NetSurfaceArea: 0.38261 m2; GrossVolume: 0.00049 m3; NetVolume: 0.00049 m3; GrossWeight: 3.91761 kg; NetWeight: 3.91761 kg
DG | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.87531; Roll: 0.69548; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1170 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.48628 m2; GrossSurfaceArea: 0.48628 m2; NetSurfaceArea: 0.48628 m2; GrossVolume: 0.00063 m3; NetVolume: 0.00063 m3; GrossWeight: 4.98218 kg; NetWeight: 4.98218 kg
DG | U110X50X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.93007; Roll: 0.64072; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1110 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.4614 m2; GrossSurfaceArea: 0.4614 m2; NetSurfaceArea: 0.4614 m2; GrossVolume: 0.0006 m3; NetVolume: 0.0006 m3; GrossWeight: 4.72668 kg; NetWeight: 4.72668 kg
2 x BNZ | U120X60X3.00 | NEW | 1.5708 | 0 | no | 945 | 0.00071 | 0.43413 | 0.43413 | 0.00064 | 0.00064 | 5.03 | 5.03
2 x BNZ | U120X60X3.00 | NEW | 0 | 1.5708 | no | 6164.1 | 0.00071 | 2.90798 | 2.90798 | 0.0043 | 0.0043 | 33.7909 | 33.7909
6 x BNZ | C120X50X20X2.65 | NEW | 0.06044 | 0 | no | 1591.06 | 0.00066 | 0.79972 | 0.79972 | 0.00105 | 0.00105 | 8.21699 | 8.21699
55 x CT | BARRA.RED.9.53 | NEW | 1.5708 | 0 | no | 200 | 0.00006 | 0.00596 | 0.00596 | 0.00001 | 0.00001 | 0.10083 | 0.10083
74 x CT | FP_K2-54-50-10-93.46 | NEW | 0 | 0.06044 | no | 50 | 0.00022 | 0.01165 | 0.01165 | 0.00001 | 0.00001 | 0.08644 | 0.08644
19 x CT | BARRA.RED.9.53 | NEW | 1.5708 | 0 | no | 180 | 0.00006 | 0.00538 | 0.00538 | 0.00001 | 0.00001 | 0.09074 | 0.09074
34 x CT | L32X3.2 | NEW | 0 | 1.5708 | no | 469.76 | 0.00019 | 0 | 0.06014 | 0.00009 | 0.00009 | 0.70065 | 0.71274
3 x CT | L32X3.2 | NEW | 0 | 1.5708 | no | 462 | 0.00019 | 0 | 0.05915 | 0.00009 | 0.00009 | 0.68907 | 0.70097
3 x CT | L32X3.2 | NEW | 0 | 1.5708 | no | 316.19 | 0.00019 | 0 | 0.04061 | 0.00006 | 0.00006 | 0.4716 | 0.47974
2 x MT | U130X40X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 530 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.22088 m2; GrossSurfaceArea: 0.22088 m2; NetSurfaceArea: 0.22088 m2; GrossVolume: 0.00028 m3; NetVolume: 0.00028 m3; GrossWeight: 2.25688 kg; NetWeight: 2.25688 kg
2 x MT | U130X40X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 600 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.2499 m2; GrossSurfaceArea: 0.2499 m2; NetSurfaceArea: 0.2499 m2; GrossVolume: 0.00033 m3; NetVolume: 0.00033 m3; GrossWeight: 2.55496 kg; NetWeight: 2.55496 kg
2 x MT | U130X40X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 725 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.30174 m2; GrossSurfaceArea: 0.30174 m2; NetSurfaceArea: 0.30174 m2; GrossVolume: 0.0004 m3; NetVolume: 0.0004 m3; GrossWeight: 3.08725 kg; NetWeight: 3.08725 kg
2 x MT | U130X40X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 1050 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.43652 m2; GrossSurfaceArea: 0.43652 m2; NetSurfaceArea: 0.43652 m2; GrossVolume: 0.00057 m3; NetVolume: 0.00057 m3; GrossWeight: 4.47119 kg; NetWeight: 4.47119 kg
2 x MT | U130X40X2.65 | NEW | 1.5708 | 0 | no | 660 | 0.00055 | 0.27479 | 0.27479 | 0.00036 | 0.00036 | 2.81046 | 2.81046
2 x MT | U130X40X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 1175 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.48836 m2; GrossSurfaceArea: 0.48836 m2; NetSurfaceArea: 0.48836 m2; GrossVolume: 0.00064 m3; NetVolume: 0.00064 m3; GrossWeight: 5.00347 kg; NetWeight: 5.00347 kg
2 x MT | U130X40X2.65 | NEW | 1.5708 | 0 | no | 790 | 0.00055 | 0.3287 | 0.3287 | 0.00043 | 0.00043 | 3.36403 | 3.36403
2 x MT | U130X40X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 920 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.38261 m2; GrossSurfaceArea: 0.38261 m2; NetSurfaceArea: 0.38261 m2; GrossVolume: 0.00049 m3; NetVolume: 0.00049 m3; GrossWeight: 3.91761 kg; NetWeight: 3.91761 kg
42 x SP | L 115X41X3.00 | NEW | 0 | 0.10094 | no | 140 | 0.00046 | 0.0446 | 0.0446 | 0.00006 | 0.00006 | 0.50444 | 0.50444
2 x MT | U140X59X4.75 | NEW | 1.5708 | 0 | no | 525 | 0.00119 | 0.25396 | 0.25396 | 0.00059 | 0.00059 | 4.60032 | 4.60032
6 x DG | U130X40X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.64346; Roll: 0.92734; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1500 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.62313 m2; GrossSurfaceArea: 0.62313 m2; NetSurfaceArea: 0.62313 m2; GrossVolume: 0.00081 m3; NetVolume: 0.00081 m3; GrossWeight: 6.38741 kg; NetWeight: 6.38741 kg
6 x DG | U130X40X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.94895; Roll: 0.62184; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 950 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.39505 m2; GrossSurfaceArea: 0.39505 m2; NetSurfaceArea: 0.39505 m2; GrossVolume: 0.00052 m3; NetVolume: 0.00052 m3; GrossWeight: 4.04536 kg; NetWeight: 4.04536 kg
6 x DG | U130X40X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.90267; Roll: 0.66813; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 900 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.37431 m2; GrossSurfaceArea: 0.37431 m2; NetSurfaceArea: 0.37431 m2; GrossVolume: 0.00049 m3; NetVolume: 0.00049 m3; GrossWeight: 3.83244 kg; NetWeight: 3.83244 kg
6 x DG | U130X40X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.85565; Roll: 0.71514; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 850 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.35358 m2; GrossSurfaceArea: 0.35358 m2; NetSurfaceArea: 0.35358 m2; GrossVolume: 0.00046 m3; NetVolume: 0.00046 m3; GrossWeight: 3.61953 kg; NetWeight: 3.61953 kg
2 x MT | U140X59X4.75 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 1348.95 mm; CrossSectionArea: 0.00119 m2; OuterSurfaceArea: 0.66957 m2; GrossSurfaceArea: 0.66957 m2; NetSurfaceArea: 0.66957 m2; GrossVolume: 0.00155 m3; NetVolume: 0.00155 m3; GrossWeight: 12.2015 kg; NetWeight: 12.2015 kg
6 x DG | U130X60X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.76386; Roll: 0.80694; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1850 mm; CrossSectionArea: 0.00065 m2; OuterSurfaceArea: 0.91649 m2; GrossSurfaceArea: 0.91649 m2; NetSurfaceArea: 0.91649 m2; GrossVolume: 0.0012 m3; NetVolume: 0.0012 m3; GrossWeight: 9.41719 kg; NetWeight: 9.41719 kg
6 x DG | U130X60X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.77017; Roll: 0.80063; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1639.75 mm; CrossSectionArea: 0.00065 m2; OuterSurfaceArea: 0.81248 m2; GrossSurfaceArea: 0.81248 m2; NetSurfaceArea: 0.81248 m2; GrossVolume: 0.00106 m3; NetVolume: 0.00106 m3; GrossWeight: 8.34693 kg; NetWeight: 8.34693 kg
6 x DG | U130X60X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.70516; Roll: 0.86564; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1550 mm; CrossSectionArea: 0.00065 m2; OuterSurfaceArea: 0.76808 m2; GrossSurfaceArea: 0.76808 m2; NetSurfaceArea: 0.76808 m2; GrossVolume: 0.00101 m3; NetVolume: 0.00101 m3; GrossWeight: 7.89008 kg; NetWeight: 7.89008 kg
6 x DG | U130X40X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.80295; Roll: 0.76785; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 800 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.33284 m2; GrossSurfaceArea: 0.33284 m2; NetSurfaceArea: 0.33284 m2; GrossVolume: 0.00043 m3; NetVolume: 0.00043 m3; GrossWeight: 3.40662 kg; NetWeight: 3.40662 kg
6 x DG | U130X40X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.02753; Roll: 0.54327; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 600 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.2499 m2; GrossSurfaceArea: 0.2499 m2; NetSurfaceArea: 0.2499 m2; GrossVolume: 0.00033 m3; NetVolume: 0.00033 m3; GrossWeight: 2.55496 kg; NetWeight: 2.55496 kg
2 x BNZ | U140X59X4.75 | NEW | 0.10094 | 1.46986 | no | 4500 | 0.00119 | 2.27321 | 2.27321 | 0.00529 | 0.00529 | 41.5403 | 41.5403
2 x BNZ | U140X57X3.75 | NEW | 0.10094 | 1.46986 | no | 3687.26 | 0.00093 | 1.84071 | 1.84071 | 0.0034 | 0.0034 | 26.6593 | 26.6593
2 x BNZ | U140X59X4.75 | NEW | 0 | 1.5708 | no | 8145.59 | 0.00119 | 4.11284 | 4.11284 | 0.00958 | 0.00958 | 75.1938 | 75.1938
12 x CT | L50X4.75 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.46986; Roll: 0.07131; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 60 mm; CrossSectionArea: 0.00046 m2; OuterSurfaceArea: 0.0129 m2; GrossSurfaceArea: 0.0129 m2; NetSurfaceArea: 0.0129 m2; GrossVolume: 0.00004 m3; NetVolume: 0.00004 m3; GrossWeight: 0.2131 kg; NetWeight: 0.2131 kg
12 x CT | L50X4.75 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.4699; Roll: 0.07128; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 60 mm; CrossSectionArea: 0.00046 m2; OuterSurfaceArea: 0.0129 m2; GrossSurfaceArea: 0.0129 m2; NetSurfaceArea: 0.0129 m2; GrossVolume: 0.00004 m3; NetVolume: 0.00004 m3; GrossWeight: 0.2131 kg; NetWeight: 0.2131 kg
4 x BNZ | U140X57X3.75 | NEW | 0 | 1.5708 | no | 8145.59 | 0.00093 | 4.06466 | 4.06466 | 0.0075 | 0.0075 | 58.9012 | 58.9012
4 x MT | U130X40X2.65 | NEW | 1.5708 | 0 | no | 1175 | 0.00055 | 0.48836 | 0.48836 | 0.00064 | 0.00064 | 5.00347 | 5.00347
4 x MT | U130X40X2.65 | NEW | 1.5708 | 0 | no | 530 | 0.00055 | 0.22088 | 0.22088 | 0.00028 | 0.00028 | 2.25688 | 2.25688
4 x MT | U130X40X2.65 | NEW | 1.5708 | 0 | no | 600 | 0.00055 | 0.2499 | 0.2499 | 0.00033 | 0.00033 | 2.55496 | 2.55496
4 x MT | U130X40X2.65 | NEW | 1.5708 | 0 | no | 725 | 0.00055 | 0.30174 | 0.30174 | 0.0004 | 0.0004 | 3.08725 | 3.08725
4 x MT | U130X40X2.65 | NEW | 1.5708 | 0 | no | 920 | 0.00055 | 0.38261 | 0.38261 | 0.00049 | 0.00049 | 3.91761 | 3.91761
4 x MT | U130X40X2.65 | NEW | 1.5708 | 0 | no | 1050 | 0.00055 | 0.43652 | 0.43652 | 0.00057 | 0.00057 | 4.47119 | 4.47119
4 x MT | U140X59X4.75 | NEW | 1.5708 | 0 | no | 1348.95 | 0.00119 | 0.66957 | 0.66957 | 0.00155 | 0.00155 | 12.2015 | 12.2015
4 x MT | U130X40X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 660 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.27479 m2; GrossSurfaceArea: 0.27479 m2; NetSurfaceArea: 0.27479 m2; GrossVolume: 0.00036 m3; NetVolume: 0.00036 m3; GrossWeight: 2.81046 kg; NetWeight: 2.81046 kg
4 x MT | U130X40X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 790 mm; CrossSectionArea: 0.00055 m2; OuterSurfaceArea: 0.3287 m2; GrossSurfaceArea: 0.3287 m2; NetSurfaceArea: 0.3287 m2; GrossVolume: 0.00043 m3; NetVolume: 0.00043 m3; GrossWeight: 3.36403 kg; NetWeight: 3.36403 kg
4 x MT | U140X59X4.75 | NEW | 1.5708 | 0 | no | 525 | 0.00119 | 0.25433 | 0.25433 | 0.00059 | 0.00059 | 4.60734 | 4.60734
4 x BNZ | U140X57X3.75 | NEW | 0.10094 | 1.46986 | no | 8187.26 | 0.00093 | 4.08484 | 4.08484 | 0.00754 | 0.00754 | 59.1932 | 59.1932
28 x TC | C120X50X20X2.65 | NEW | 0 | 0.10094 | no | 4200 | 0.00066 | 2.11854 | 2.11854 | 0.00278 | 0.00278 | 21.7902 | 21.7902
24 x CR | L43X2.65 | NEW | 0.10094 | 1.46986 | no | 1262.85 | 0.00022 | 0.21765 | 0.21765 | 0.00028 | 0.00028 | 2.18964 | 2.18964
32 x SPT | G 60X50X70X6.35 | NEW | 1.46986 | 0.0504 | no | 50 | 0.00109 | 0.02001 | 0.02001 | 0.00004 | 0.00004 | 0.42856 | 0.42856
16 x TR | BARRA.RED.9.53 | NEW | 0.06121 | 1.46986 | no | 2000 | 0.00006 | 0.05848 | 0.05848 | 0.00014 | 0.00014 | 1.00826 | 1.00826
8 x CV | BARRA.RED.9.53 | NEW | 0.07171 | 0.07768 | no | 5300 | 0.00006 | 0.15476 | 0.15476 | 0.00033 | 0.00033 | 2.67188 | 2.67188
4 x CV | BARRA.RED.9.53 | NEW | 0.06784 | 0.07768 | no | 5300 | 0.00006 | 0.15476 | 0.15476 | 0.00033 | 0.00033 | 2.67188 | 2.67188
2 x CV | BARRA.RED.9.53 | NEW | 0.06787 | 0.07152 | no | 5300 | 0.00006 | 0.15476 | 0.15476 | 0.00033 | 0.00033 | 2.67188 | 2.67188
2 x CV | BARRA.RED.9.53 | NEW | 0.06784 | 0.07152 | no | 5300 | 0.00006 | 0.15476 | 0.15476 | 0.00033 | 0.00033 | 2.67188 | 2.67188
8 x MF | L50X3.0 | NEW | 0.50071 | 1.07006 | no | 1525 | 0.00029 | 0.30558 | 0.30558 | 0.00043 | 0.00043 | 3.48363 | 3.48363
8 x MF | L50X3.0 | NEW | 0.5744 | 0.99638 | no | 1590 | 0.00029 | 0.31858 | 0.31858 | 0.00046 | 0.00046 | 3.63212 | 3.63212
8 x MF | L50X3.0 | NEW | 0.64115 | 0.92963 | no | 1670 | 0.00029 | 0.33458 | 0.33458 | 0.00049 | 0.00049 | 3.81486 | 3.81486
8 x MF | L50X3.0 | NEW | 0.70184 | 0.86895 | no | 1750 | 0.00029 | 0.35058 | 0.35058 | 0.00051 | 0.00051 | 3.99761 | 3.99761
8 x MF | L50X3.0 | NEW | 0.75691 | 0.81388 | no | 1840 | 0.00029 | 0.36858 | 0.36858 | 0.00054 | 0.00054 | 4.2032 | 4.2032
8 x MF | L50X3.0 | NEW | 0.81468 | 0.7561 | no | 1920 | 0.00029 | 0.38458 | 0.38458 | 0.00056 | 0.00056 | 4.38595 | 4.38595
8 x DG | U170X70X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.26651; Roll: 0.30428; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 375 mm; CrossSectionArea: 0.00081 m2; OuterSurfaceArea: 0.23213 m2; GrossSurfaceArea: 0.23213 m2; NetSurfaceArea: 0.23213 m2; GrossVolume: 0.00031 m3; NetVolume: 0.00031 m3; GrossWeight: 2.37695 kg; NetWeight: 2.37695 kg
4 x DG | U170X70X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 1.26651; Roll: 0.30428; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 980 mm; CrossSectionArea: 0.00081 m2; OuterSurfaceArea: 0.60402 m2; GrossSurfaceArea: 0.60402 m2; NetSurfaceArea: 0.60402 m2; GrossVolume: 0.00078 m3; NetVolume: 0.00078 m3; GrossWeight: 6.21175 kg; NetWeight: 6.21175 kg
4 x CT | L90X70X4.75 | NEW | 0 | 0 | no | 180 | 0.00177 | 0 | 0.05907 | 0.00032 | 0.00014 | 2.50101 | 1.042
8 x DG | U170X70X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.87521; Roll: 0.69559; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1200 mm; CrossSectionArea: 0.00081 m2; OuterSurfaceArea: 0.73925 m2; GrossSurfaceArea: 0.73925 m2; NetSurfaceArea: 0.73925 m2; GrossVolume: 0.00097 m3; NetVolume: 0.00097 m3; GrossWeight: 7.60623 kg; NetWeight: 7.60623 kg
8 x DG | U170X70X2.65 | PredefinedType: BEAM; Pset_MemberCommon - Status: NEW; Slope: 0.85226; Roll: 0.71854; IsExternal: no; LoadBearing: no; Qto_MemberBaseQuantities - Length: 1240 mm; CrossSectionArea: 0.00081 m2; OuterSurfaceArea: 0.76384 m2; GrossSurfaceArea: 0.76384 m2; NetSurfaceArea: 0.76384 m2; GrossVolume: 0.001 m3; NetVolume: 0.001 m3; GrossWeight: 7.85977 kg; NetWeight: 7.85977 kg
4 x MT | U170X70X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 960 mm; CrossSectionArea: 0.00081 m2; OuterSurfaceArea: 0.59173 m2; GrossSurfaceArea: 0.59173 m2; NetSurfaceArea: 0.59173 m2; GrossVolume: 0.00078 m3; NetVolume: 0.00078 m3; GrossWeight: 6.08498 kg; NetWeight: 6.08498 kg
6 x MT | U170X40X2.65 | NEW | 1.5708 | 0 | no | 960 | 0.00064 | 0 | 0.47621 | 0.00062 | 0.00062 | 4.8155 | 4.88676
8 x MT | U170X70X2.65 | NEW | 1.5708 | 0 | no | 960 | 0.00081 | 0.59173 | 0.59173 | 0.00078 | 0.00078 | 6.08498 | 6.08498
2 x BNZ | U180X80X4.75 | NEW | 0 | 1.5708 | no | 8500 | 0.00159 | 5.675 | 5.675 | 0.01328 | 0.01328 | 104.242 | 104.242
4 x MT | U180X80X4.75 | NEW | 1.5708 | 0 | no | 1000 | 0.00159 | 0.6484 | 0.6484 | 0.00151 | 0.00151 | 11.8573 | 11.8573
2 x BNZ | U180X67X3.75 | NEW | 0 | 1.5708 | no | 8500 | 0.00111 | 0 | 5.25368 | 0.00946 | 0.00973 | 74.2649 | 76.3537
6 x MT | U170X40X2.65 | PredefinedType: BEAM; Pset_ColumnCommon - Status: NEW; Slope: 1.5708; Roll: 0; IsExternal: no; LoadBearing: no; Qto_ColumnBaseQuantities - Length: 960 mm; CrossSectionArea: 0.00064 m2; OuterSurfaceArea: 0 m2; GrossSurfaceArea: 0 m2; NetSurfaceArea: 0.47621 m2; GrossVolume: 0.00062 m3; NetVolume: 0.00062 m3; GrossWeight: 4.8155 kg; NetWeight: 4.88676 kg
98 x CHUMBADOR QUIMICO | BARRA.RED.22 | NEW | 1.5708 | 0 | no | 250 | 0.00036 | 0.01781 | 0.01781 | 0.00009 | 0.00009 | 0.71239 | 0.71239
102 x CHUMBADOR QUIMICO | BARRA.RED.22 | NEW | 0 | 0.09361 | no | 200 | 0.00036 | 0.01439 | 0.01439 | 0.00006 | 0.00006 | 0.56991 | 0.56991
86 x CHUMBADOR QUIMICO | BARRA.RED.12.7 | NEW | 0 | 0.09361 | no | 150 | 0.00011 | 0.00606 | 0.00606 | 0.00002 | 0.00002 | 0.13429 | 0.13429
18 x CHUMBADOR QUIMICO | BARRA.RED.19 | NEW | 0 | 0.09361 | no | 200 | 0.00027 | 0.01234 | 0.01234 | 0.00004 | 0.00004 | 0.42508 | 0.42508
2 x TC | C120X50X20X2.65 | NEW | 0 | 0.06043 | no | 4245 | 0.00066 | 2.14123 | 2.14123 | 0.00281 | 0.00281 | 22.0237 | 22.0237
2 x CR | L43X2.65 | NEW | 0.06036 | 1.51044 | no | 1632.73 | 0.00022 | 0.28127 | 0.28127 | 0.00036 | 0.00036 | 2.83097 | 2.83097

# IfcPlate (1091)
In: COBERTURA
Material: ASTM A36
Pset_PlateCommon - Status: NEW; IsExternal: no; LoadBearing: no
Name | Description | Width (mm) | Perimeter (mm) | GrossArea (m2) | NetArea (m2) | GrossVolume (m3) = NetVolume (m3) | GrossWeight (kg) | NetWeight (kg)
CHAPA | CH9.52 | 9.52 | 1260 | 0.098 | 0.208 | 0.00093 | 7.32374 | 7.32374
340 x CHAPA | CH6.35 | 6.35 | 249.061 | 0.0048 | 0.00798 | 0.00002 | 0.23928 | 0.16077
27 x CHAPA | CH6.35 | 6.35 | 330 | 0.00605 | 0.01363 | 0.00004 | 0.30158 | 0.29036
74 x CHAPA | CH12.7 | 12.7 | 759.999 | 0.028 | 0.06565 | 0.00036 | 2.79152 | 2.79149
8 x CHAPA | CH6.35 | 6.35 | 249.061 | 0.0048 | 0.00778 | 0.00002 | 0.23928 | 0.15641
108 x CHAPA | CH6.35 | 6.35 | 281.925 | 0.0064 | 0.01037 | 0.00004 | 0.31903 | 0.21373
16 x CHAPA | CH6.35 | 6.35 | 330 | 0.00605 | 0.01325 | 0.00004 | 0.30158 | 0.28164
292 x CR | CH4.75 | 4.75 | 300 | 0.0054 | 0.01222 | 0.00004 | 0.20135 | 0.20135
2 x CHAPA | CH9.52 | 9.52 | 820 | 0.0418 | 0.09141 | 0.0004 | 3.1238 | 3.1238
10 x CHAPA | CH9.52 | 9.52 | 799.999 | 0.0336 | 0.07482 | 0.00032 | 2.51104 | 2.51102
3 x CHAPA | CH12.7 | 12.7 | 799.999 | 0.0336 | 0.07736 | 0.00043 | 3.34982 | 3.34978
6 x CHAPA | CH3 | 3 | 140 | 0.00123 | 0.00287 | 0 | 0.02885 | 0.02885
8 x CHAPA | CH9.52 | 9.52 | 720 | 0.0324 | 0.07165 | 0.00031 | 2.42132 | 2.42132
8 x CHAPA | CH6.35 | 6.35 | 592.132 | 0.0289 | 0.03859 | 0.00011 | 1.44059 | 0.86984
30 x CHAPA | CH12.7 | 12.7 | 920 | 0.048 | 0.10768 | 0.00062 | 4.78536 | 4.78536
12 x CHAPA | CH6.35 | 6.35 | 360 | 0.00688 | 0.01509 | 0.00004 | 0.3427 | 0.32276
48 x CHAPA | CH6.35 | 6.35 | 252.111 | 0.0048 | 0.00833 | 0.00002 | 0.23927 | 0.16948
24 x CHAPA | CH6.35 | 6.35 | 399.284 | 0.0105 | 0.01656 | 0.00004 | 0.5234 | 0.35142
12 x CHAPA | CH6.35 | 6.35 | 511.485 | 0.02239 | 0.03063 | 0.00009 | 1.11586 | 0.68248
12 x CHAPA | CH6.35 | 6.35 | 523.876 | 0.0225 | 0.03143 | 0.00009 | 1.1217 | 0.70043
8 x CHAPA | CH3.75 | 3.75 | 1000 | 0.0525 | 0.10875 | 0.00019 | 1.54547 | 1.54547
32 x CHAPA | CH6.35 | 6.35 | 413.178 | 0.012 | 0.01835 | 0.00004 | 0.59817 | 0.3938
6 x CHAPA | CH15.88 | 15.88 | 920 | 0.048 | 0.11061 | 0.00076 | 5.98358 | 5.98358
4 x CHAPA | CH6.35 | 6.35 | 720 | 0.0324 | 0.06937 | 0.00022 | 1.61506 | 1.61506

# IfcRoof (252)
In: COBERTURA
PredefinedType: FLAT_ROOF
Pset_BeamCommon - Status: NEW; IsExternal: no; LoadBearing: no
Name | Description | Material | Slope | Roll | Length (mm) | CrossSectionArea (m2) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetSurfaceArea (m2) | GrossVolume (m3) | NetVolume (m3) | GrossWeight (kg) | NetWeight (kg)
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06154 | 0 | 8250 | 0.03142 | 0.00002 | 14.3437 | 0.25921 | 0.17744 | 714.114 | 488.845
55 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06154 | 0 | 8250 | 0.03142 | 0.00002 | 19.9133 | 0.25921 | 0.25921 | 714.114 | 714.116
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06154 | 0 | 8600 | 0.03142 | 0.00002 | 20.6346 | 0.2702 | 0.26824 | 744.41 | 738.996
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06154 | 0 | 8600 | 0.03142 | 0.00002 | 20.7554 | 0.2702 | 0.2702 | 744.41 | 744.412
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06154 | 0 | 8600 | 0.03142 | 0.00002 | 20.423 | 0.2702 | 0.26664 | 744.41 | 734.588
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06154 | 0 | 8250 | 0.03142 | 0.00002 | 16.3427 | 0.25921 | 0.21463 | 714.114 | 591.297
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06154 | 0 | 5605 | 0.03142 | 0.00001 | 6.21128 | 0.1761 | 0.08537 | 485.165 | 235.207
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 410 | 0.03142 | 0 | 1.04934 | 0.01288 | 0.01288 | 35.4893 | 35.4894
34 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2300 | 0.03142 | 0.00001 | 5.5969 | 0.07226 | 0.07226 | 199.086 | 199.087
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2680 | 0.03142 | 0.00001 | 6.36969 | 0.0842 | 0.08334 | 231.979 | 229.597
6 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2680 | 0.03142 | 0.00001 | 6.51122 | 0.0842 | 0.0842 | 231.979 | 231.98
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2680 | 0.03142 | 0.00001 | 6.15927 | 0.0842 | 0.07908 | 231.979 | 217.855
TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2300 | 0.03142 | 0.00001 | 4.13127 | 0.07226 | 0.05058 | 199.086 | 139.357
TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2300 | 0.03142 | 0.00001 | 2.03757 | 0.07226 | 0.02788 | 199.086 | 76.8164
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2680 | 0.03142 | 0.00001 | 5.81856 | 0.0842 | 0.07531 | 231.979 | 207.477
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2680 | 0.03142 | 0.00001 | 5.91199 | 0.0842 | 0.07522 | 231.979 | 207.225
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2300 | 0.03142 | 0.00001 | 3.1996 | 0.07226 | 0.03553 | 199.086 | 97.8931
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 450 | 0.03142 | 0 | 0.53083 | 0.01414 | 0.00532 | 38.9517 | 14.6616
8 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 1900 | 0.03142 | 0 | 4.63445 | 0.0597 | 0.0597 | 164.463 | 164.463
TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 1900 | 0.03142 | 0 | 2.19162 | 0.0597 | 0.02261 | 164.463 | 62.3014
6 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06154 | 0 | 6875 | 0.03142 | 0.00002 | 16.6049 | 0.21601 | 0.21601 | 595.095 | 595.097
TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06154 | 0 | 8250 | 0.03142 | 0.00002 | 17.9928 | 0.25921 | 0.23001 | 714.114 | 633.681
6 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 1800 | 0.03142 | 0 | 4.39384 | 0.05655 | 0.05655 | 155.807 | 155.807
TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 1800 | 0.03142 | 0 | 0.77525 | 0.05655 | 0.00415 | 155.807 | 11.4435
TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2300 | 0.03142 | 0.00001 | 2.38237 | 0.07226 | 0.03174 | 199.086 | 87.4509
TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 200 | 0.03142 | 0 | 0.22386 | 0.00628 | 0.0027 | 17.3119 | 7.43442
TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 200 | 0.03142 | 0 | 0.54406 | 0.00628 | 0.00628 | 17.3119 | 17.3119
TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.06043 | 0 | 2300 | 0.03142 | 0.00001 | 4.27591 | 0.07226 | 0.05247 | 199.086 | 144.55
CL | FP_P50*50*300-188.76*209.29--113.58--111.37-110.12-107.91-0.5 | ALUZINCO | 0 | 0 | 13775.9 | 0.0004 | 22.0011 | 22.0011 | 0.0055 | 0.0055 | 15.1432 | 15.1432
CL | FP_P50*50*300-188.76*209.29--113.58--111.37-110.12-107.91-0.5 | ALUZINCO | 0 | 0 | 13812.6 | 0.0004 | 22.0596 | 22.0596 | 0.0055 | 0.0055 | 15.1835 | 15.1835
CL | FP_P50*50*300-188.76*209.29-159.88--111.37-110.12-107.91-0.5 | ALUZINCO | 0 | 0 | 8881.28 | 0.0004 | 14.1769 | 14.1769 | 0.00354 | 0.00354 | 9.75768 | 9.75768
CL | FP_P50*50*230-188.76*209.29--113.58-180-110.12-90-0.5 | ALUZINCO | 0 | 0 | 8501.44 | 0.00036 | 12.3793 | 12.3793 | 0.00309 | 0.00309 | 8.51989 | 8.51989
CL | FP_P50*50*300-188.76*209.29--113.58--111.37-110.12-107.91-0.5 | ALUZINCO | 0 | 0 | 14821.8 | 0.0004 | 23.6714 | 23.6714 | 0.00591 | 0.00591 | 16.2929 | 16.2929
CL | FP_P50*50*300-188.76*209.29--113.58--111.37-110.12-107.91-0.5 | ALUZINCO | 0 | 0 | 15088.8 | 0.0004 | 24.0978 | 24.0978 | 0.00602 | 0.00602 | 16.5864 | 16.5864
CL | FP_P185*50*168-200*134-180--111.37-90-107.91-0.5 | ALUZINCO | 0 | 0 | 6567.19 | 0.00037 | 9.68048 | 9.68048 | 0.00242 | 0.00242 | 6.6624 | 6.6624
RF | FP_P10*50*154-51*50-90-180-130.15-143.31-0.5 | ALUZINCO | 0 | 0.93048 | 6144.81 | 0.00016 | 3.86665 | 3.86665 | 0.00097 | 0.00097 | 2.65871 | 2.65871
CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 1326.96 | 0.00016 | 0.76074 | 0.76074 | 0.00019 | 0.00019 | 0.52287 | 0.52287
CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 1573.84 | 0.00016 | 0.92102 | 0.92102 | 0.00022 | 0.00022 | 0.63309 | 0.63309
CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 6150.99 | 0.00016 | 3.8055 | 3.8055 | 0.00095 | 0.00095 | 2.61666 | 2.61666
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 5396.69 | 0.00016 | 3.30411 | 3.30411 | 0.00082 | 0.00082 | 2.27185 | 2.27185
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 5396.57 | 0.00016 | 3.30403 | 3.30403 | 0.00082 | 0.00082 | 2.2718 | 2.2718
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 5396.49 | 0.00016 | 3.30398 | 3.30398 | 0.00082 | 0.00082 | 2.27176 | 2.27176
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 5394.05 | 0.00016 | 3.30242 | 3.30242 | 0.00082 | 0.00082 | 2.27069 | 2.27069
4 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 2505.17 | 0.00016 | 1.469 | 1.469 | 0.00038 | 0.00038 | 1.00991 | 1.00991
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0.00001 | 0.06043 | 1263.3 | 0.00016 | 0.65265 | 0.65265 | 0.00016 | 0.00016 | 0.44851 | 0.44851
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0.00001 | 0.06043 | 1263.14 | 0.00016 | 0.65255 | 0.65255 | 0.00016 | 0.00016 | 0.44844 | 0.44844
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 27096.7 | 0.00016 | 17.2241 | 17.2241 | 0.0043 | 0.0043 | 11.8443 | 11.8443
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 2547.31 | 0.00016 | 1.49602 | 1.49602 | 0.00038 | 0.00038 | 1.02849 | 1.02849
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 5396.63 | 0.00016 | 3.30408 | 3.30408 | 0.00082 | 0.00082 | 2.27183 | 2.27183
4 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0 | 0.06043 | 1242.07 | 0.00016 | 0.63904 | 0.63904 | 0.00016 | 0.00016 | 0.43914 | 0.43914
4 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06154 | 0 | 5622.8 | 0.00016 | 3.53755 | 3.53755 | 0.00088 | 0.00088 | 2.43243 | 2.43243
4 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06154 | 0 | 2909.57 | 0.00016 | 1.70598 | 1.70598 | 0.00043 | 0.00043 | 1.17285 | 1.17285
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06154 | 0 | 598.157 | 0.00016 | 0.22339 | 0.22339 | 0.00006 | 0.00006 | 0.15331 | 0.15331
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06154 | 0 | 598.157 | 0.00016 | 0.22341 | 0.22341 | 0.00006 | 0.00006 | 0.15332 | 0.15332
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0 | 448.752 | 0.00016 | 0.21887 | 0.21887 | 0.00004 | 0.00004 | 0.15026 | 0.15026
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0 | 2148.54 | 0.00016 | 1.2179 | 1.2179 | 0.00031 | 0.00031 | 0.83721 | 0.83721
4 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0 | 591.153 | 0.00016 | 0.21897 | 0.21897 | 0.00004 | 0.00004 | 0.15027 | 0.15027
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0.00006 | 591.153 | 0.00016 | 0.21897 | 0.21897 | 0.00004 | 0.00004 | 0.15027 | 0.15027
RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0.00006 | 2346.83 | 0.00016 | 1.43632 | 1.43632 | 0.00036 | 0.00036 | 0.98747 | 0.98747
RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0 | 2346.81 | 0.00016 | 1.43632 | 1.43632 | 0.00036 | 0.00036 | 0.98747 | 0.98747
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0.00006 | 591.167 | 0.00016 | 0.21897 | 0.21897 | 0.00004 | 0.00004 | 0.15027 | 0.15027
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0.00006 | 2148.54 | 0.00016 | 1.2179 | 1.2179 | 0.00031 | 0.00031 | 0.83721 | 0.83721
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0.00006 | 448.752 | 0.00016 | 0.21887 | 0.21887 | 0.00004 | 0.00004 | 0.15026 | 0.15026
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0 | 1900 | 0.00016 | 1.21901 | 1.21901 | 0.00031 | 0.00031 | 0.83806 | 0.83806
RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0.00006 | 2363.27 | 0.00016 | 1.35756 | 1.35756 | 0.00033 | 0.00033 | 0.93325 | 0.93325
RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06043 | 0 | 2368.54 | 0.00016 | 1.35901 | 1.35901 | 0.00033 | 0.00033 | 0.93425 | 0.93425
2 x CL | FP_P25*30*150-65*50--90--135-93.46-180-0.5 | ALUZINCO | 0.06043 | 0 | 1816.98 | 0.00016 | 1.09561 | 1.09561 | 0.00026 | 0.00026 | 0.75317 | 0.75317
2 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.06154 | 0 | 1223.97 | 0.00016 | 0.83416 | 0.78324 | 0.00022 | 0.00019 | 0.57341 | 0.53839
16 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.10094 | 0 | 7950 | 0.03142 | 0.00002 | 19.1914 | 0.24978 | 0.24978 | 688.146 | 688.148
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA | ALUZINCO | 0.10094 | 0 | 7950 | 0.03142 | 0.00002 | 7.66806 | 0.24978 | 0.07559 | 688.146 | 208.248
2 x CL | FP_P50*50*350-125*350--95.78-180-95.36-84.63-0.5 | ALUZINCO | 0 | 0.09361 | 8409.8 | 0.00046 | 15.5582 | 15.5582 | 0.00389 | 0.00389 | 10.7093 | 10.7093
CL | FP_P35*35*150-300*150-135-135-168.43-180-0.5 | ALUZINCO | 0 | 0.10094 | 8408.99 | 0.00033 | 11.2693 | 11.2693 | 0.00281 | 0.00281 | 7.75548 | 7.75548
4 x RF | FP_P25*30*150-65*50--90--135-90-180-0.5 | ALUZINCO | 0.10094 | 0 | 7989.49 | 0.00016 | 5.12135 | 5.12135 | 0.00128 | 0.00128 | 3.52161 | 3.52161
2 x RF | FP_P15*15*205-30*110-150-150-85-95-0.5 | ASTM A36 | 0 | 0.08727 | 8500.01 | 0.00019 | 6.36226 | 6.36226 | 0.00159 | 0.00159 | 12.4685 | 12.4685

# IfcVoidingFeature (27)
In: COBERTURA
PredefinedType: HOLE
Name | Description
25 x CHAPA | CH500
2 x TL | TELHA TP-40 #0.5 + PIR 30 + BANDEJA
